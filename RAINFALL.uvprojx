# Keil uVision project RAINFALL.uvprojx, settings and files
target RAINFALL (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F051C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: RAINFALL
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ./SRC/: main.c it.c param.c
  group BSP
    ./SRC/: bsp.c
  group RTC
    ./SRC/: rtc.c
  group UART
    ./SRC/: uart.c
  group FLASH
    ./SRC/: flash.c
  group MG301
    ./SRC/: mg301.c
  group CRC16
    ./SRC/: crc16.c
  group ADC
    ./SRC/: adc.c
software components: CMSIS:CORE 4.3.0, Device:Startup 2.2.3
